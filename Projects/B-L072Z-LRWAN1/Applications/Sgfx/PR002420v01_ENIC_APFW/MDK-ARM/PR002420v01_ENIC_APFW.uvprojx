# Keil uVision project PR002420v01_ENIC_APFW.uvprojx, settings and files
target mlm32l07x01 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x00030000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PR002420v01_ENIC_APFW +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx,USE_B_L072Z_LRWAN1, USE_FULL_LL_DRIVER, USE_RADIO_LL_DRIVER
  c misc: --C99
  c include: ..\inc;..\..\..\..\..\..\Drivers\BSP\MLM32L07X01;..\..\..\..\..\..\Drivers\BSP\Components\sx1276;..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\BSP\B-L072Z-LRWAN1;..\..\..\..\..\..\Middlewares\Third_Party\Sgfx\utils;..\..\..\..\..\..\Middlewares\Third_Party\Sgfx\SigfoxLib;..\..\..\..\..\..\Middlewares\Third_Party\Sgfx\Crypto;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Drivers\BSP\B-L072Z-LRWAN1;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A2;..\..\Common\cwmx1zzabz\Radio_Sigfox_Driver;..\..\Common\cwmx1zzabz\Credentials_libs;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x17000
  memory RVCT5: ROM 0x8017000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\NUCLEO_CUBE_SGFX.sct
  link misc: --diag_suppress=L6329 --keep app_crc.o(.constdata)
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/sx1276/: sx1276.c
  group Drivers/BSP/X_NUCLEO_IKS01A2
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers_BSP_B-L072Z-LRWAN1
    ../../../../../../Drivers/BSP/B-L072Z-LRWAN1/: b-l072z-lrwan1.c
  group Drivers_BSP_MLM32L0X01
    ../../../../../../Drivers/BSP/MLM32L07X01/: mlm32l07x01.c
  group Drivers_CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers_STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_adc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_rcc.c stm32l0xx_ll_dma.c stm32l0xx_ll_spi.c stm32l0xx_hal_iwdg.c stm32l0xx_ll_gpio.c
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/: stm32l0xx_hal_usart.h stm32l0xx_hal_gpio.h stm32l0xx_ll_gpio.h
  group Projects_MDK-ARM
    ./: startup_stm32l072xx.s
  group PR002420v01_ENIC_APFW
    ../src/: app_crc.c at.c bsp.c cm.c command.c ct.c debug.c dl.c eeprom.c gwh0079.c hw_eeprom.c hw_gpio.c hw_rtc.c hw_spi.c led.c iwdg.c main.c mfg.c mlm32l0xx_hal_msp.c mlm32l0xx_hw.c mlm32l0xx_it.c hw_tim2.c tiny_sscanf.c tiny_vsnprintf.c util.c timer.c rep.c spi.c system.c nic.c ul.c ucp.c vcom.c
    ../../Common/cwmx1zzabz/Radio_Sigfox_Driver/: mcu_api.c rf_api.c st_lowlevel.c SgfxSTModemSx1276V123_CM0_Keil_O3.lib
    ../../Common/cwmx1zzabz/Credentials_libs/: SgfxCredentialsV011_CM0_Keil_O3.lib
  group Middlewares_Lib
    ../../../../../../Middlewares/Third_Party/Sgfx/SigfoxLib/: SgfxCoreV231_CM0_Keil.lib
    ../../../../../../Middlewares/Third_Party/Sgfx/SigfoxLibTest/: SgfxAddonV020_CM0_Keil.lib
  group Middlewares_Utilities
    ../../../../../../Middlewares/Third_Party/Sgfx/utils/: scheduler.c timeServer.c utilities.c low_power_manager.c
  group Middlewares_Crypto
    ../../../../../../Middlewares/Third_Party/Sgfx/Crypto/: SgfxCmacV100_CM0_Keil_O3.lib sigfox_data.c se_nvm.c
